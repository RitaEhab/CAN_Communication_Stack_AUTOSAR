# Keil uVision project L.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: L
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s utilities.h utilities.c transmitmain.c Std_types.h PduR_Types.h PduR_PbCfg.h PduR_PbCfg.c PduR_Cfg.h PduR_CanIf.h Pdur.h Pdur.c Com.h Com_Types.h Com_PbCfg.c Com_PbCfg.h ComStack_Types.h Com.c CanIf.h CanIf_Cbk.h CanIf_Cfg.c CanIf.c CanIf_Types.h Can_GeneralTypes.h Can_Cfg.h Can_PBcfg.h CanIf_Cfg.h Can_CanIf.h Can_PBcfg.c Can.h Can.c Rom.h
    ../EE319Kware/driverlib/: uart.h uart.c gpio.h interrupt.h sysctl.h
